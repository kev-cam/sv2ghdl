model \mymod!name resistor r=1k
