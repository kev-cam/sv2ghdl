* t
.param y = {a+b}
R1 a b r='c*2'
