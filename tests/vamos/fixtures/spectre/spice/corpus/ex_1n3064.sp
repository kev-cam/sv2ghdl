* adding a title
.model 1N3064  D(Is=0.1p Rs=4 CJO=1p Tt=8n Bv=100 Ibv=0.1p)
*          85-??-??   Original library
