* t
.param x = (a+b
R1 a b 1k
