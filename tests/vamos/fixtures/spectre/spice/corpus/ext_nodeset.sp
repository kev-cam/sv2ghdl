* t
.nodeset V(1)=0.5 V(out)=0.3
