* t
.param x = a>1 ? sqrt(b+1) : (c-2)
