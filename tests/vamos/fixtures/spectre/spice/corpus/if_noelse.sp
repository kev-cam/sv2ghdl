* t
.if (a>1)
R1 a b 1k
.endif

