* t
.param x = 1k + 2*3
