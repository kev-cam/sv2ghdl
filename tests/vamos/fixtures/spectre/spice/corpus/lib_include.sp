* t
.lib "file.lib" section

