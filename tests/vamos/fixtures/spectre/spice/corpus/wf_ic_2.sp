* t
.ic v(a:b)=0

