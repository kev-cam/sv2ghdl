* t
R1 a b 1k
.model
R2 a b 2k
