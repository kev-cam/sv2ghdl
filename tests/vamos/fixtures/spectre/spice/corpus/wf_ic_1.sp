* t
.ic v(out)=1.5

