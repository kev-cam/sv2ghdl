* t
.subckt inv a y
R1 a y 1k
.ends
