* t
.param x = a+
R1 a b 1k
