* t
.meas tran res1 FIND v(out) AT=5m

