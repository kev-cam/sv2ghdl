* t
.ic v(*)=0 v(1*)=1.2 v(out)=2*3

