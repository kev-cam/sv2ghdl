* t
.lib mylib
R1 a b 1k
.endl

